# Keil uVision project project.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: R7FA6M4AF3CFB Renesas
  pack: Renesas.RA_DFP.3.1.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: __RTTHREAD__, RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  c include: rt-thread\components\libc\compilers\common;rt-thread\components\libc\compilers\common\extension;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;board;board\ports;libraries\HAL_Drivers;libraries\HAL_Drivers\config;rt-thread\components\finsh;.;rt-thread\include;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\posix\io\stdio;rt-thread\components\libc\posix\ipc
  library: MicroLIB
  scatter file: .\script\fsp.scat
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscalls.c syscall_mem.c
    rt-thread/components/libc/compilers/common/: stdlib.c time.c
  group CPU
    rt-thread/libcpu/arm/common/: showmem.c backtrace.c div0.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/ipc/: waitqueue.c ringblk_buf.c dataqueue.c completion.c ringbuffer.c workqueue.c pipe.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial_v2.c
  group Drivers
    libraries/HAL_Drivers/: drv_gpio.c drv_usart_v2.c drv_common.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c cmd.c
  group Kernel
    rt-thread/src/: object.c kservice.c irq.c timer.c scheduler.c device.c ipc.c mem.c components.c idle.c clock.c thread.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Flex Software:RA Configuration 1.0.0
