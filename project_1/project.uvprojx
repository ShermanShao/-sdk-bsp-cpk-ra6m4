# Keil uVision project project.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: R7FA6M4AF3CFB Renesas
  pack: Renesas.RA_DFP.3.1.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: __RTTHREAD__, RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  c include: packages\ali-iotkit-latest\iotkit-embedded\src\infra;packages\ali-iotkit-latest\iotkit-embedded\src\mqtt\impl;packages\ali-iotkit-latest\iotkit-embedded\src\mqtt;packages\ali-iotkit-latest\iotkit-embedded\src\dev_model;packages\ali-iotkit-latest\iotkit-embedded\src\dev_model\client;packages\ali-iotkit-latest\iotkit-embedded\src\dev_model\server;packages\ali-iotkit-latest\iotkit-embedded\src\dev_sign;packages\ali-iotkit-latest\iotkit-embedded\wrappers;packages\cJSON-v1.7.14;rt-thread\components\libc\compilers\common;rt-thread\components\libc\compilers\common\extension;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\wlan;board;board\ports;libraries\HAL_Drivers;libraries\HAL_Drivers\config;rt-thread\components\dfs\include;rt-thread\components\finsh;packages\isl29035-latest;.;rt-thread\include;rt-thread\components\net\lwip\lwip-2.0.3\src;rt-thread\components\net\lwip\lwip-2.0.3\src\include;rt-thread\components\net\lwip\lwip-2.0.3\src\include\ipv4;rt-thread\components\net\lwip\lwip-2.0.3\src\arch\include;rt-thread\components\net\lwip\lwip-2.0.3\src\include\netif;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\posix\io\stdio;rt-thread\components\libc\posix\ipc;packages\rw007-latest;packages\rw007-latest\inc;rt-thread\components\net\netdev\include;rt-thread\components\net\sal\include;rt-thread\components\net\sal\include\socket;rt-thread\components\net\sal\impl;rt-thread\components\net\sal\include\dfs_net;rt-thread\components\net\sal\include\socket\sys_socket;rt-thread\components\drivers\sensors;rt-thread\components\drivers\include
  library: MicroLIB
  scatter file: .\script\fsp.scat
  group ali-iotkit
    packages/ali-iotkit-latest/iotkit-embedded/src/infra/: infra_cjson.c infra_log.c infra_compat.c infra_report.c infra_net.c infra_defs.c infra_string.c infra_prt_nwk_payload.c infra_sha256.c infra_timer.c
    packages/ali-iotkit-latest/iotkit-embedded/src/dev_model/: dm_message.c dm_utils.c dm_ipc.c dm_cota.c dm_api.c dm_fota.c iotx_cm_mqtt.c dm_message_cache.c impl_linkkit.c dm_log_report.c iotx_cm.c dm_ota.c dm_msg_process.c dm_opt.c dm_manager.c
    packages/ali-iotkit-latest/iotkit-embedded/src/mqtt/impl/: iotx_mqtt_client.c MQTTDeserializePublish.c MQTTConnectClient.c MQTTUnsubscribeClient.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTPacket.c
    packages/ali-iotkit-latest/ports/rtthread/: HAL_TCP_rtthread.c HAL_OS_rtthread.c HAL_UDP_rtthread.c
    packages/ali-iotkit-latest/iotkit-embedded/src/dev_sign/: dev_sign_mqtt.c
    packages/ali-iotkit-latest/iotkit-embedded/src/dev_model/client/: dm_client_adapter.c dm_client.c
    packages/ali-iotkit-latest/iotkit-embedded/src/mqtt/: mqtt_api.c
    packages/ali-iotkit-latest/ports/: wrapper.c
  group cJSON
    packages/cJSON-v1.7.14/: cJSON.c cJSON_port.c cJSON_Utils.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: stdlib.c time.c
  group CPU
    rt-thread/libcpu/arm/common/: showmem.c backtrace.c div0.c
    rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/ipc/: waitqueue.c dataqueue.c ringblk_buf.c ringbuffer.c completion.c workqueue.c pipe.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial_v2.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    rt-thread/components/drivers/wlan/: wlan_dev.c wlan_workqueue.c wlan_cfg.c wlan_prot.c wlan_lwip.c wlan_cmd.c wlan_mgnt.c
  group Drivers
    board/ports/: drv_rw007.c
    libraries/HAL_Drivers/: drv_gpio.c drv_usart_v2.c drv_spi.c drv_common.c drv_soft_i2c.c
  group Filesystem
    rt-thread/components/dfs/src/: dfs_posix.c dfs_fs.c dfs.c dfs_file.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_file.c cmd.c
  group isl29035
    packages/isl29035-latest/: isl29035.c sensor_renesas_isl29035.c
  group Kernel
    rt-thread/src/: object.c idle.c mem.c ipc.c scheduler.c timer.c clock.c device.c kservice.c thread.c components.c irq.c
  group lwIP
    rt-thread/components/net/lwip/lwip-2.0.3/src/api/: netdb.c sockets.c netifapi.c tcpip.c netbuf.c api_lib.c err.c api_msg.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/: ip.c netif.c sys.c init.c memp.c raw.c tcp_out.c inet_chksum.c stats.c tcp_in.c dns.c timeouts.c udp.c pbuf.c def.c tcp.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c ip4_addr.c dhcp.c etharp.c ip4.c ip4_frag.c icmp.c igmp.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c ethernetif.c lowpan6.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/arch/: sys_arch.c
  group POSIX
    rt-thread/components/libc/posix/io/poll/: select.c poll.c
  group rt_kprintf
    packages/rt_vsnprintf_full-latest/: rt_vsnprintf.c
  group rw007
    packages/rw007-latest/src/: spi_wifi_rw007.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev_ipaddr.c netdev.c
    rt-thread/components/net/sal/dfs_net/: dfs_net.c
    rt-thread/components/net/sal/src/: sal_socket.c
    rt-thread/components/net/sal/socket/: net_sockets.c net_netdb.c
    rt-thread/components/net/sal/impl/: af_inet_lwip.c
  group Sensors
    rt-thread/components/drivers/sensors/: sensor_cmd.c sensor.c
software components: Flex Software:RA Configuration 1.0.0
